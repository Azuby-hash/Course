# Keil uVision project demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: demo +hex
  c flags: Optim=1
  c include: .;..\include;..\Source\include;..\Source\portable\RVDS\ARM7_LPC21xx
  asm include: ..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group main
    ./: LPC2300.s main.c
    ./ParTest/: ParTest.c
  group Free RTOS
    ../Source/: tasks.c list.c queue.c croutine.c
    ../Source/portable/MemMang/: heap_2.c
    ../Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
  group Minimal
    ../Minimal/: semtest.c BlockQ.c dynamic.c flash.c PollQ.c
  group Other
    ./: delay.h ExInt.h ADC.h lcd.h serial.h
